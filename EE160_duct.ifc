Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Wed Sep 16 09:10:01 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE160_D
In: Default Storey
PTC_Identity Data - MODEL_CHECK: Mi Mai 21 2008 13:47:51; MEASURAND1: Relative Humidity; Working range 10…95 % r.h.; MEASURAND2: Temperature; Measuring range -40...60 °C (-40...140 °F); OUTPUT1: Analogue voltage / current; 0-10 V / 4-20 mA (2-wire); OUTPUT2: Digital interface; RS485 with Modbus RTU or BACnet MS/TP; SUPPLY: 24 V AC ±20 % / 15-35 V DC; ENCLOSUREMATERIAL: Polycarbonate / without display UL94V-0 approved; ENCLOSUREDIMENSIONS: WxHxD = 80.6x101x46 mm (3.17x3.98x1.81"); ENCLOSUREDESIGNSTANDARD: Cover: light grey RAL7035; housing: E+E green RAL6018; VOLUME: 360407; SURFACE_AREA: 40058.9; MASS: 360407; DENSITY: 1; CENTRE_OF_GRAVITY_X: 11.0481; CENTRE_OF_GRAVITY_Y: -0.4299; CENTRE_OF_GRAVITY_Z: 1.2354
